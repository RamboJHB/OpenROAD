VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MANUFACTURINGGRID 0.001 ;

LAYER VTL_N
  TYPE IMPLANT ;
  WIDTH 0.600 ;
  SPACING 0.100 ;
END VTL_N
LAYER VTL_P
  TYPE IMPLANT ;
  WIDTH 0.600 ;
  SPACING 0.100 ;
END VTL_P
LAYER VTH_N
  TYPE IMPLANT ;
  WIDTH 0.600 ;
  SPACING 0.100 ;
END VTH_N
LAYER VTH_P
  TYPE IMPLANT ;
  WIDTH 0.600 ;
  SPACING 0.100 ;
END VTH_P

SITE core
  CLASS CORE ;
  SIZE 0.100 BY 1.000 ;
  SYMMETRY X Y ;
END core

MACRO TL4
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.400 BY 1.000 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER VTL_N ; RECT 0 0 0.400 0.500 ;
    LAYER VTL_P ; RECT 0 0.500 0.400 1.000 ;
  END
END TL4

MACRO TH4
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.400 BY 1.000 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER VTH_N ; RECT 0 0 0.400 0.500 ;
    LAYER VTH_P ; RECT 0 0.500 0.400 1.000 ;
  END
END TH4

MACRO FL1
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  SIZE 0.100 BY 1.000 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER VTL_N ; RECT 0 0 0.100 0.500 ;
    LAYER VTL_P ; RECT 0 0.500 0.100 1.000 ;
  END
END FL1

MACRO FL2
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  SIZE 0.200 BY 1.000 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER VTL_N ; RECT 0 0 0.200 0.500 ;
    LAYER VTL_P ; RECT 0 0.500 0.200 1.000 ;
  END
END FL2

MACRO FH1
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  SIZE 0.100 BY 1.000 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER VTH_N ; RECT 0 0 0.100 0.500 ;
    LAYER VTH_P ; RECT 0 0.500 0.100 1.000 ;
  END
END FH1

MACRO FH2
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  SIZE 0.200 BY 1.000 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER VTH_N ; RECT 0 0 0.200 0.500 ;
    LAYER VTH_P ; RECT 0 0.500 0.200 1.000 ;
  END
END FH2

END LIBRARY
