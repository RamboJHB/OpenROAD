VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 2000 ;
END UNITS

SITE DPL_TEST_SITE
  CLASS CORE ;
  SYMMETRY X Y ;
  SIZE 0.19 BY 1.4 ;
END DPL_TEST_SITE

MACRO FILLER_X1
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  FOREIGN FILLER_X1 0 0 ;
  SIZE 0.19 BY 1.4 ;
  SYMMETRY X Y ;
  SITE DPL_TEST_SITE ;
END FILLER_X1

MACRO FILLER_X2_H2
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  FOREIGN FILLER_X2_H2 0 0 ;
  SIZE 0.38 BY 2.8 ;
  SYMMETRY X Y ;
  SITE DPL_TEST_SITE ;
END FILLER_X2_H2

END LIBRARY
