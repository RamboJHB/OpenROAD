VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MANUFACTURINGGRID 0.001 ;

LAYER metal1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  WIDTH 0.05 ;
END metal1

LAYER LVT
  TYPE IMPLANT ;
END LVT

LAYER HVT
  TYPE IMPLANT ;
END HVT

SITE core
  CLASS CORE ;
  SYMMETRY Y ;
  SIZE 0.2 BY 1.0 ;
END core

# ---- standard cell (LVT, 2 sites) ----
MACRO CELL_L
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.4 BY 1.0 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER LVT ;
      RECT 0 0 0.4 1.0 ;
  END
END CELL_L

# ---- LVT fillers (2 / 4 / 6 sites) ----
MACRO FILL_L2
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  SIZE 0.4 BY 1.0 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER LVT ;
      RECT 0 0 0.4 1.0 ;
  END
END FILL_L2

MACRO FILL_L4
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  SIZE 0.8 BY 1.0 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER LVT ;
      RECT 0 0 0.8 1.0 ;
  END
END FILL_L4

MACRO FILL_L6
  CLASS CORE SPACER ;
  ORIGIN 0 0 ;
  SIZE 1.2 BY 1.0 ;
  SYMMETRY X Y ;
  SITE core ;
  OBS
    LAYER LVT ;
      RECT 0 0 1.2 1.0 ;
  END
END FILL_L6

END LIBRARY
